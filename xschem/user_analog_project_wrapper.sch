v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 3620 300 3630 300 {
lab=vssa2}
N 3620 350 3630 350 {
lab=vssa1}
N 3620 400 3630 400 {
lab=vssa2}
N 3620 450 3630 450 {
lab=vssa2}
N 3620 280 3630 280 {
lab=vccd2}
N 3620 330 3630 330 {
lab=vccd1}
N 3620 380 3630 380 {
lab=vdda2}
N 3620 430 3630 430 {
lab=vdda2}
N 3930 280 3940 280 {
lab=v02}
N 3930 330 3940 330 {
lab=v04}
N 3930 380 3940 380 {
lab=v25}
N 3930 430 3940 430 {
lab=v3}
N 3980 560 3990 560 {
lab=la_data_in[0]}
N 3980 580 3990 580 {
lab=la_data_in[1]}
N 3980 600 3990 600 {
lab=la_data_in[2]}
N 3980 620 3990 620 {
lab=la_data_in[3]}
N 3980 640 3990 640 {
lab=la_data_in[4]}
N 3980 660 3990 660 {
lab=la_data_in[5]}
N 3980 680 3990 680 {
lab=la_data_in[6]}
N 3980 700 3990 700 {
lab=la_data_in[7]}
N 3980 720 3990 720 {
lab=la_data_in[8]}
N 3980 740 3990 740 {
lab=la_data_in[9]}
N 3980 760 3990 760 {
lab=la_data_in[10]}
N 3980 780 3990 780 {
lab=la_data_in[11]}
N 3980 800 3990 800 {
lab=la_data_in[12]}
N 3980 820 3990 820 {
lab=la_data_in[13]}
N 3980 840 3990 840 {
lab=la_data_in[14]}
N 3980 860 3990 860 {
lab=la_data_in[15]}
N 3980 880 3990 880 {
lab=la_data_in[16]}
N 3980 900 3990 900 {
lab=la_data_in[17]}
N 3980 920 3990 920 {
lab=la_data_in[18]}
N 3980 940 3990 940 {
lab=la_data_in[19]}
N 3980 960 3990 960 {
lab=la_data_in[20]}
N 3980 980 3990 980 {
lab=la_data_in[21]}
N 3980 1000 3990 1000 {
lab=la_data_in[22]}
N 3980 1020 3990 1020 {
lab=la_data_in[23]}
N 3980 1040 3990 1040 {
lab=la_data_in[24]}
N 3980 1040 3980 1060 {
lab=la_data_in[24]}
N 3980 1060 3990 1060 {
lab=la_data_in[24]}
N 3980 1080 3990 1080 {
lab=la_data_in[25]}
N 3980 1080 3980 1100 {
lab=la_data_in[25]}
N 3980 1100 3990 1100 {
lab=la_data_in[25]}
N 4290 560 4300 560 {
lab=la_data_out[32]}
N 4290 580 4300 580 {
lab=la_data_out[33]}
N 4290 600 4300 600 {
lab=la_data_out[34]}
N 4290 620 4300 620 {
lab=la_data_out[35]}
N 4290 640 4300 640 {
lab=la_data_out[36]}
N 4290 660 4300 660 {
lab=la_data_out[37]}
N 4290 680 4300 680 {
lab=la_data_out[38]}
N 4290 700 4300 700 {
lab=la_data_out[39]}
N 3970 1200 3990 1200 {
lab=v02}
N 3980 1180 3990 1180 {
lab=v3}
N 3980 1160 3990 1160 {
lab=v25}
N 3980 1120 3980 1160 {
lab=v25}
N 3980 1120 3990 1120 {
lab=v25}
N 3970 1140 3990 1140 {
lab=vccd2}
N 4290 720 4300 720 {
lab=vdda2}
N 4290 780 4300 780 {
lab=vdda2}
N 4290 800 4300 800 {
lab=vccd2}
N 4290 820 4300 820 {
lab=vssa2}
N 4290 860 4300 860 {
lab=vssa2}
N 4290 880 4300 880 {
lab=vssa2}
N 4290 900 4300 900 {
lab=vssa2}
N 4290 920 4300 920 {
lab=vssa2}
N 4290 940 4300 940 {
lab=vssa2}
N 4300 920 4300 940 {
lab=vssa2}
N 4300 900 4300 920 {
lab=vssa2}
N 4300 880 4300 900 {
lab=vssa2}
N 4300 820 4300 860 {
lab=vssa2}
N 4290 840 4310 840 {
lab=io_analog[5]}
N 4300 720 4300 780 {
lab=vdda2}
N 4290 740 4310 740 {
lab=vccd2}
N 4310 740 4310 800 {
lab=vccd2}
N 4300 800 4310 800 {
lab=vccd2}
N 4290 760 4320 760 {
lab=v25}
N 4300 860 4300 880 {
lab=vssa2}
N 4640 560 4650 560 {
lab=la_data_in[83]}
N 4640 580 4650 580 {
lab=la_data_in[84]}
N 4640 600 4650 600 {
lab=la_data_in[85]}
N 4640 620 4650 620 {
lab=la_data_in[86]}
N 4640 640 4650 640 {
lab=la_data_in[87]}
N 4640 660 4650 660 {
lab=la_data_in[88]}
N 4640 680 4650 680 {
lab=la_data_in[89]}
N 4640 700 4650 700 {
lab=la_data_in[90]}
N 4640 720 4650 720 {
lab=la_data_in[91]}
N 4640 740 4650 740 {
lab=la_data_in[92]}
N 4640 760 4650 760 {
lab=la_data_in[93]}
N 4640 780 4650 780 {
lab=la_data_in[94]}
N 4640 800 4650 800 {
lab=la_data_in[95]}
N 4640 820 4650 820 {
lab=la_data_in[96]}
N 4640 840 4650 840 {
lab=la_data_in[97]}
N 4640 860 4650 860 {
lab=la_data_in[98]}
N 4640 880 4650 880 {
lab=la_data_in[99]}
N 4640 900 4650 900 {
lab=la_data_in[100]}
N 4640 920 4650 920 {
lab=la_data_in[101]}
N 4640 940 4650 940 {
lab=la_data_in[102]}
N 4640 960 4650 960 {
lab=la_data_in[103]}
N 4640 980 4650 980 {
lab=la_data_in[104]}
N 4640 1000 4650 1000 {
lab=la_data_in[105]}
N 4640 1020 4650 1020 {
lab=la_data_in[106]}
N 4640 1040 4650 1040 {
lab=la_data_in[107]}
N 4640 1060 4650 1060 {
lab=la_data_in[107]}
N 4640 1080 4650 1080 {
lab=la_data_in[108]}
N 4640 1100 4650 1100 {
lab=la_data_in[108]}
N 4640 1080 4640 1100 {
lab=la_data_in[108]}
N 4640 1040 4640 1060 {
lab=la_data_in[107]}
N 4950 560 4960 560 {
lab=la_data_out[113]}
N 4950 580 4960 580 {
lab=la_data_out[114]}
N 4950 600 4960 600 {
lab=la_data_out[115]}
N 4950 620 4960 620 {
lab=la_data_out[116]}
N 4950 640 4960 640 {
lab=la_data_out[117]}
N 4950 660 4960 660 {
lab=la_data_out[118]}
N 4950 680 4960 680 {
lab=la_data_out[119]}
N 4950 700 4960 700 {
lab=la_data_out[120]}
N 4640 1120 4650 1120 {
lab=v25}
N 4640 1120 4640 1160 {
lab=v25}
N 4640 1160 4650 1160 {
lab=v25}
N 4630 1140 4650 1140 {
lab=vccd1}
N 4640 1180 4650 1180 {
lab=v3}
N 4640 1200 4650 1200 {
lab=v04}
N 4950 720 4960 720 {
lab=vdda1}
N 4960 720 4960 780 {
lab=vdda1}
N 4950 780 4960 780 {
lab=vdda1}
N 4950 740 4970 740 {
lab=vccd1}
N 4970 740 4970 800 {
lab=vccd1}
N 4950 800 4970 800 {
lab=vccd1}
N 4950 760 4980 760 {
lab=v25}
N 4950 820 4970 820 {
lab=vssa1}
N 4970 820 4970 840 {
lab=vssa1}
N 4950 840 4970 840 {
lab=vssa1}
N 4950 860 4970 860 {
lab=vssa1}
N 4970 840 4970 860 {
lab=vssa1}
N 4950 880 4960 880 {
lab=vssa1}
N 4960 880 4970 880 {
lab=vssa1}
N 4970 860 4970 880 {
lab=vssa1}
N 4950 900 4970 900 {
lab=vssa1}
N 4970 880 4970 900 {
lab=vssa1}
N 4950 940 4970 940 {
lab=vssa1}
N 4970 900 4970 940 {
lab=vssa1}
N 4950 920 4980 920 {
lab=io_analog[5]}
N 3860 1310 3870 1310 {
lab=gpio_analog[0]}
N 3860 1380 3870 1380 {
lab=gpio_analog[7]}
N 4460 1330 4470 1330 {
lab=gpio_analog[0]}
N 5090 1330 5100 1330 {
lab=gpio_analog[0]}
N 5090 1350 5100 1350 {
lab=gpio_analog[1]}
N 4340 140 4350 140 {
lab=gpio_analog[0]}
N 4340 180 4350 180 {
lab=gpio_analog[1]}
N 4340 260 4350 260 {
lab=gpio_analog[2]}
N 4340 200 4350 200 {
lab=gpio_analog[3]}
N 4840 260 4850 260 {
lab=gpio_analog[2]}
N 4840 240 4850 240 {
lab=gpio_analog[3]}
N 4840 140 4850 140 {
lab=gpio_analog[0]}
N 4840 180 4850 180 {
lab=gpio_analog[1]}
N 5090 1310 5100 1310 {
lab=gpio_analog[4]}
N 5400 1330 5410 1330 {
lab=io_analog[9]}
N 4340 220 4350 220 {
lab=io_analog[0]}
N 4340 240 4350 240 {
lab=io_analog[1]}
N 4840 220 4850 220 {
lab=io_analog[2]}
N 4840 200 4850 200 {
lab=io_analog[3]}
N 4770 1310 4780 1310 {
lab=io_analog[8]}
N 4170 1330 4180 1330 {
lab=io_analog[7]}
N 4460 1400 4470 1400 {
lab=gpio_analog[7]}
N 5090 1400 5100 1400 {
lab=gpio_analog[7]}
N 5090 1420 5100 1420 {
lab=gpio_analog[8]}
N 4340 300 4350 300 {
lab=gpio_analog[7]}
N 4340 340 4350 340 {
lab=gpio_analog[8]}
N 4340 420 4350 420 {
lab=gpio_analog[9]}
N 4340 360 4350 360 {
lab=gpio_analog[10]}
N 4840 300 4850 300 {
lab=gpio_analog[7]}
N 4840 340 4850 340 {
lab=gpio_analog[8]}
N 4840 420 4850 420 {
lab=gpio_analog[9]}
N 4840 400 4850 400 {
lab=gpio_analog[10]}
N 5090 1380 5100 1380 {
lab=gpio_analog[11]}
N 4340 380 4350 380 {
lab=gpio_analog[12]}
N 4340 400 4350 400 {
lab=gpio_analog[13]}
N 4840 380 4850 380 {
lab=gpio_analog[14]}
N 4840 360 4850 360 {
lab=gpio_analog[15]}
N 4170 1400 4180 1400 {
lab=io_analog[10]}
N 4770 1380 4780 1380 {
lab=gpio_analog[16]}
N 5400 1400 5410 1400 {
lab=gpio_analog[17]}
N 4170 1310 4180 1310 {
lab=vccd2}
N 4170 1350 4180 1350 {
lab=vssa2}
N 4460 1310 4470 1310 {
lab=vccd2}
N 4460 1350 4470 1350 {
lab=vssa2}
N 5400 1310 5410 1310 {
lab=vdda2}
N 5400 1350 5410 1350 {
lab=vssa2}
N 4340 160 4350 160 {
lab=vssa1}
N 4840 160 4850 160 {
lab=vssa1}
N 4170 1380 4180 1380 {
lab=vccd2}
N 4170 1420 4180 1420 {
lab=vssa2}
N 4460 1420 4470 1420 {
lab=vssa2}
N 5400 1420 5410 1420 {
lab=vssa2}
N 4340 320 4350 320 {
lab=vssa2}
N 4840 320 4850 320 {
lab=vssa2}
N 4460 1380 4470 1380 {
lab=vccd2}
N 5400 1380 5410 1380 {
lab=vdda2}
C {devices/iopin.sym} 3370 340 0 0 {name=p1 lab=vdda1}
C {devices/iopin.sym} 3370 370 0 0 {name=p2 lab=vdda2}
C {devices/iopin.sym} 3370 400 0 0 {name=p3 lab=vssa1}
C {devices/iopin.sym} 3370 430 0 0 {name=p4 lab=vssa2}
C {devices/iopin.sym} 3370 460 0 0 {name=p5 lab=vccd1}
C {devices/iopin.sym} 3370 490 0 0 {name=p6 lab=vccd2}
C {devices/iopin.sym} 3370 520 0 0 {name=p7 lab=vssd1}
C {devices/iopin.sym} 3370 550 0 0 {name=p8 lab=vssd2}
C {devices/ipin.sym} 3420 620 0 0 {name=p9 lab=wb_clk_i}
C {devices/ipin.sym} 3420 650 0 0 {name=p10 lab=wb_rst_i}
C {devices/ipin.sym} 3420 680 0 0 {name=p11 lab=wbs_stb_i}
C {devices/ipin.sym} 3420 710 0 0 {name=p12 lab=wbs_cyc_i}
C {devices/ipin.sym} 3420 740 0 0 {name=p13 lab=wbs_we_i}
C {devices/ipin.sym} 3420 770 0 0 {name=p14 lab=wbs_sel_i[3:0]}
C {devices/ipin.sym} 3420 800 0 0 {name=p15 lab=wbs_dat_i[31:0]}
C {devices/ipin.sym} 3420 830 0 0 {name=p16 lab=wbs_adr_i[31:0]}
C {devices/opin.sym} 3410 890 0 0 {name=p17 lab=wbs_ack_o}
C {devices/opin.sym} 3410 920 0 0 {name=p18 lab=wbs_dat_o[31:0]}
C {devices/ipin.sym} 3420 960 0 0 {name=p19 lab=la_data_in[127:0]}
C {devices/opin.sym} 3410 990 0 0 {name=p20 lab=la_data_out[127:0]}
C {devices/ipin.sym} 3420 1070 0 0 {name=p21 lab=io_in[26:0]}
C {devices/ipin.sym} 3420 1100 0 0 {name=p22 lab=io_in_3v3[26:0]}
C {devices/ipin.sym} 3410 1380 0 0 {name=p23 lab=user_clock2}
C {devices/opin.sym} 3410 1130 0 0 {name=p24 lab=io_out[26:0]}
C {devices/opin.sym} 3410 1160 0 0 {name=p25 lab=io_oeb[26:0]}
C {devices/iopin.sym} 3380 1220 0 0 {name=p26 lab=gpio_analog[17:0]}
C {devices/iopin.sym} 3380 1250 0 0 {name=p27 lab=gpio_noesd[17:0]}
C {devices/iopin.sym} 3380 1280 0 0 {name=p29 lab=io_analog[10:0]}
C {devices/iopin.sym} 3380 1310 0 0 {name=p30 lab=io_clamp_high[2:0]}
C {devices/iopin.sym} 3380 1340 0 0 {name=p31 lab=io_clamp_low[2:0]}
C {devices/opin.sym} 3400 1410 0 0 {name=p32 lab=user_irq[2:0]}
C {devices/ipin.sym} 3420 1020 0 0 {name=p28 lab=la_oenb[127:0]}
C {vDivider_3.sym} 3780 440 0 0 {name=x5}
C {vDivider_25.sym} 3780 390 0 0 {name=x6}
C {vDivider_02.sym} 3780 290 0 0 {name=x7}
C {vDivider_04.sym} 3780 340 0 0 {name=x8}
C {devices/lab_pin.sym} 3620 450 0 0 {name=l27 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 3620 400 0 0 {name=l28 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 3620 350 0 0 {name=l29 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} 3620 300 0 0 {name=l30 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 3620 280 0 0 {name=l31 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 3620 330 0 0 {name=l32 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} 3620 380 0 0 {name=l33 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} 3620 430 0 0 {name=l34 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} 3940 280 2 0 {name=l35 sig_type=std_logic lab=v02}
C {devices/lab_pin.sym} 3940 330 2 0 {name=l36 sig_type=std_logic lab=v04}
C {devices/lab_pin.sym} 3940 380 2 0 {name=l37 sig_type=std_logic lab=v25}
C {devices/lab_pin.sym} 3940 430 2 0 {name=l38 sig_type=std_logic lab=v3}
C {02Compute.sym} 4140 880 0 0 {name=x1}
C {devices/lab_pin.sym} 3980 560 0 0 {name=l1 sig_type=std_logic lab=la_data_in[0]}
C {devices/lab_pin.sym} 3980 580 0 0 {name=l2 sig_type=std_logic lab=la_data_in[1]}
C {devices/lab_pin.sym} 3980 600 0 0 {name=l3 sig_type=std_logic lab=la_data_in[2]}
C {devices/lab_pin.sym} 3980 620 0 0 {name=l4 sig_type=std_logic lab=la_data_in[3]}
C {devices/lab_pin.sym} 3980 640 0 0 {name=l5 sig_type=std_logic lab=la_data_in[4]}
C {devices/lab_pin.sym} 3980 660 0 0 {name=l6 sig_type=std_logic lab=la_data_in[5]}
C {devices/lab_pin.sym} 3980 680 0 0 {name=l7 sig_type=std_logic lab=la_data_in[6]}
C {devices/lab_pin.sym} 3980 700 0 0 {name=l8 sig_type=std_logic lab=la_data_in[7]}
C {devices/lab_pin.sym} 3980 720 0 0 {name=l9 sig_type=std_logic lab=la_data_in[8]}
C {devices/lab_pin.sym} 3980 740 0 0 {name=l10 sig_type=std_logic lab=la_data_in[9]}
C {devices/lab_pin.sym} 3980 760 0 0 {name=l11 sig_type=std_logic lab=la_data_in[10]}
C {devices/lab_pin.sym} 3980 780 0 0 {name=l12 sig_type=std_logic lab=la_data_in[11]}
C {devices/lab_pin.sym} 3980 800 0 0 {name=l13 sig_type=std_logic lab=la_data_in[12]}
C {devices/lab_pin.sym} 3980 820 0 0 {name=l14 sig_type=std_logic lab=la_data_in[13]}
C {devices/lab_pin.sym} 3980 840 0 0 {name=l15 sig_type=std_logic lab=la_data_in[14]}
C {devices/lab_pin.sym} 3980 860 0 0 {name=l16 sig_type=std_logic lab=la_data_in[15]}
C {devices/lab_pin.sym} 3980 880 0 0 {name=l17 sig_type=std_logic lab=la_data_in[16]}
C {devices/lab_pin.sym} 3980 900 0 0 {name=l18 sig_type=std_logic lab=la_data_in[17]}
C {devices/lab_pin.sym} 3980 920 0 0 {name=l19 sig_type=std_logic lab=la_data_in[18]}
C {devices/lab_pin.sym} 3980 940 0 0 {name=l20 sig_type=std_logic lab=la_data_in[19]}
C {devices/lab_pin.sym} 3980 960 0 0 {name=l21 sig_type=std_logic lab=la_data_in[20]}
C {devices/lab_pin.sym} 3980 980 0 0 {name=l22 sig_type=std_logic lab=la_data_in[21]}
C {devices/lab_pin.sym} 3980 1000 0 0 {name=l23 sig_type=std_logic lab=la_data_in[22]}
C {devices/lab_pin.sym} 3980 1020 0 0 {name=l24 sig_type=std_logic lab=la_data_in[23]}
C {devices/lab_pin.sym} 3980 1040 0 0 {name=l25 sig_type=std_logic lab=la_data_in[24]}
C {devices/lab_pin.sym} 3980 1080 0 0 {name=l26 sig_type=std_logic lab=la_data_in[25]}
C {devices/lab_pin.sym} 4300 560 2 0 {name=l39 sig_type=std_logic lab=la_data_out[32]}
C {devices/lab_pin.sym} 4300 580 2 0 {name=l40 sig_type=std_logic lab=la_data_out[33]}
C {devices/lab_pin.sym} 4300 600 2 0 {name=l41 sig_type=std_logic lab=la_data_out[34]}
C {devices/lab_pin.sym} 4300 620 2 0 {name=l42 sig_type=std_logic lab=la_data_out[35]}
C {devices/lab_pin.sym} 4300 640 2 0 {name=l43 sig_type=std_logic lab=la_data_out[36]}
C {devices/lab_pin.sym} 4300 660 2 0 {name=l44 sig_type=std_logic lab=la_data_out[37]}
C {devices/lab_pin.sym} 4300 680 2 0 {name=l45 sig_type=std_logic lab=la_data_out[38]}
C {devices/lab_pin.sym} 4300 700 2 0 {name=l46 sig_type=std_logic lab=la_data_out[39]}
C {devices/lab_pin.sym} 3970 1200 0 0 {name=l47 sig_type=std_logic lab=v02}
C {devices/lab_pin.sym} 3980 1180 0 0 {name=l48 sig_type=std_logic lab=v3}
C {devices/lab_pin.sym} 3980 1160 0 0 {name=l49 sig_type=std_logic lab=v25}
C {devices/lab_pin.sym} 3970 1140 0 0 {name=l50 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 4300 720 2 0 {name=l51 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} 4310 740 2 0 {name=l53 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 4320 760 2 0 {name=l52 sig_type=std_logic lab=v25}
C {devices/lab_pin.sym} 4300 880 2 0 {name=l54 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 4310 840 2 0 {name=l55 sig_type=std_logic lab=io_analog[5]}
C {04Compute.sym} 4800 880 0 0 {name=x2}
C {devices/lab_pin.sym} 4640 560 0 0 {name=l56 sig_type=std_logic lab=la_data_in[83]}
C {devices/lab_pin.sym} 4640 580 0 0 {name=l57 sig_type=std_logic lab=la_data_in[84]}
C {devices/lab_pin.sym} 4640 600 0 0 {name=l58 sig_type=std_logic lab=la_data_in[85]}
C {devices/lab_pin.sym} 4640 620 0 0 {name=l59 sig_type=std_logic lab=la_data_in[86]}
C {devices/lab_pin.sym} 4640 640 0 0 {name=l60 sig_type=std_logic lab=la_data_in[87]}
C {devices/lab_pin.sym} 4640 660 0 0 {name=l61 sig_type=std_logic lab=la_data_in[88]}
C {devices/lab_pin.sym} 4640 680 0 0 {name=l62 sig_type=std_logic lab=la_data_in[89]}
C {devices/lab_pin.sym} 4640 700 0 0 {name=l63 sig_type=std_logic lab=la_data_in[90]}
C {devices/lab_pin.sym} 4640 720 0 0 {name=l64 sig_type=std_logic lab=la_data_in[91]}
C {devices/lab_pin.sym} 4640 740 0 0 {name=l65 sig_type=std_logic lab=la_data_in[92]}
C {devices/lab_pin.sym} 4640 760 0 0 {name=l66 sig_type=std_logic lab=la_data_in[93]}
C {devices/lab_pin.sym} 4640 780 0 0 {name=l67 sig_type=std_logic lab=la_data_in[94]}
C {devices/lab_pin.sym} 4640 800 0 0 {name=l68 sig_type=std_logic lab=la_data_in[95]}
C {devices/lab_pin.sym} 4640 820 0 0 {name=l69 sig_type=std_logic lab=la_data_in[96]}
C {devices/lab_pin.sym} 4640 840 0 0 {name=l70 sig_type=std_logic lab=la_data_in[97]}
C {devices/lab_pin.sym} 4640 860 0 0 {name=l71 sig_type=std_logic lab=la_data_in[98]}
C {devices/lab_pin.sym} 4640 880 0 0 {name=l72 sig_type=std_logic lab=la_data_in[99]}
C {devices/lab_pin.sym} 4640 900 0 0 {name=l73 sig_type=std_logic lab=la_data_in[100]}
C {devices/lab_pin.sym} 4640 920 0 0 {name=l74 sig_type=std_logic lab=la_data_in[101]}
C {devices/lab_pin.sym} 4640 940 0 0 {name=l75 sig_type=std_logic lab=la_data_in[102]}
C {devices/lab_pin.sym} 4640 960 0 0 {name=l76 sig_type=std_logic lab=la_data_in[103]}
C {devices/lab_pin.sym} 4640 980 0 0 {name=l77 sig_type=std_logic lab=la_data_in[104]}
C {devices/lab_pin.sym} 4640 1000 0 0 {name=l78 sig_type=std_logic lab=la_data_in[105]}
C {devices/lab_pin.sym} 4640 1020 0 0 {name=l79 sig_type=std_logic lab=la_data_in[106]}
C {devices/lab_pin.sym} 4640 1040 0 0 {name=l80 sig_type=std_logic lab=la_data_in[107]}
C {devices/lab_pin.sym} 4640 1080 0 0 {name=l81 sig_type=std_logic lab=la_data_in[108]}
C {devices/lab_pin.sym} 4960 560 2 0 {name=l82 sig_type=std_logic lab=la_data_out[113]}
C {devices/lab_pin.sym} 4960 580 2 0 {name=l83 sig_type=std_logic lab=la_data_out[114]}
C {devices/lab_pin.sym} 4960 600 2 0 {name=l84 sig_type=std_logic lab=la_data_out[115]}
C {devices/lab_pin.sym} 4960 620 2 0 {name=l85 sig_type=std_logic lab=la_data_out[116]}
C {devices/lab_pin.sym} 4960 640 2 0 {name=l86 sig_type=std_logic lab=la_data_out[117]}
C {devices/lab_pin.sym} 4960 660 2 0 {name=l87 sig_type=std_logic lab=la_data_out[118]}
C {devices/lab_pin.sym} 4960 680 2 0 {name=l88 sig_type=std_logic lab=la_data_out[119]}
C {devices/lab_pin.sym} 4960 700 2 0 {name=l89 sig_type=std_logic lab=la_data_out[120]}
C {devices/lab_pin.sym} 4640 1200 0 0 {name=l90 sig_type=std_logic lab=v04}
C {devices/lab_pin.sym} 4640 1180 0 0 {name=l91 sig_type=std_logic lab=v3}
C {devices/lab_pin.sym} 4640 1120 0 0 {name=l92 sig_type=std_logic lab=v25}
C {devices/lab_pin.sym} 4630 1140 0 0 {name=l93 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} 4960 720 2 0 {name=l94 sig_type=std_logic lab=vdda1}
C {devices/lab_pin.sym} 4970 740 2 0 {name=l95 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} 4980 760 2 0 {name=l96 sig_type=std_logic lab=v25}
C {devices/lab_pin.sym} 4980 920 2 0 {name=l97 sig_type=std_logic lab=io_analog[5]}
C {devices/lab_pin.sym} 4970 820 2 0 {name=l98 sig_type=std_logic lab=vssa1}
C {Buffer.sym} 4020 1330 0 0 {name=x3}
C {Buffer.sym} 4020 1400 0 0 {name=x4}
C {oneBitADC.sym} 4620 1330 0 0 {name=x9}
C {oneBitADC.sym} 4620 1400 0 0 {name=x10}
C {2-1MUX.sym} 5250 1330 0 0 {name=x11}
C {2-1MUX.sym} 5250 1400 0 0 {name=x12}
C {4T4R.sym} 4190 360 0 0 {name=x13}
C {4T4R.sym} 4190 200 0 0 {name=x14}
C {4T4RLarge.sym} 4690 360 0 0 {name=x15}
C {4T4RLarge.sym} 4690 200 0 0 {name=x16}
C {devices/lab_pin.sym} 3860 1310 0 0 {name=l99 sig_type=std_logic lab=gpio_analog[0]}
C {devices/lab_pin.sym} 4460 1330 0 0 {name=l100 sig_type=std_logic lab=gpio_analog[0]}
C {devices/lab_pin.sym} 5090 1330 0 0 {name=l101 sig_type=std_logic lab=gpio_analog[0]}
C {devices/lab_pin.sym} 5090 1350 0 0 {name=l102 sig_type=std_logic lab=gpio_analog[1]}
C {devices/lab_pin.sym} 4350 140 2 0 {name=l103 sig_type=std_logic lab=gpio_analog[0]}
C {devices/lab_pin.sym} 4350 180 2 0 {name=l104 sig_type=std_logic lab=gpio_analog[1]}
C {devices/lab_pin.sym} 4350 260 2 0 {name=l105 sig_type=std_logic lab=gpio_analog[2]}
C {devices/lab_pin.sym} 4350 200 2 0 {name=l106 sig_type=std_logic lab=gpio_analog[3]}
C {devices/lab_pin.sym} 4850 260 2 0 {name=l107 sig_type=std_logic lab=gpio_analog[2]}
C {devices/lab_pin.sym} 4850 240 2 0 {name=l108 sig_type=std_logic lab=gpio_analog[3]}
C {devices/lab_pin.sym} 4850 140 2 0 {name=l109 sig_type=std_logic lab=gpio_analog[0]}
C {devices/lab_pin.sym} 4850 180 2 0 {name=l110 sig_type=std_logic lab=gpio_analog[1]}
C {devices/lab_pin.sym} 5090 1310 0 0 {name=l111 sig_type=std_logic lab=gpio_analog[4]}
C {devices/lab_pin.sym} 5410 1330 2 0 {name=l112 sig_type=std_logic lab=io_analog[9]}
C {devices/lab_pin.sym} 4350 220 2 0 {name=l113 sig_type=std_logic lab=io_analog[0]}
C {devices/lab_pin.sym} 4350 240 2 0 {name=l114 sig_type=std_logic lab=io_analog[1]}
C {devices/lab_pin.sym} 4850 220 2 0 {name=l115 sig_type=std_logic lab=io_analog[2]}
C {devices/lab_pin.sym} 4850 200 2 0 {name=l116 sig_type=std_logic lab=io_analog[3]}
C {devices/lab_pin.sym} 4780 1310 2 0 {name=l117 sig_type=std_logic lab=io_analog[8]}
C {devices/lab_pin.sym} 4180 1330 2 0 {name=l118 sig_type=std_logic lab=io_analog[7]}
C {devices/lab_pin.sym} 3860 1380 0 0 {name=l119 sig_type=std_logic lab=gpio_analog[7]}
C {devices/lab_pin.sym} 4460 1400 0 0 {name=l120 sig_type=std_logic lab=gpio_analog[7]}
C {devices/lab_pin.sym} 5090 1400 0 0 {name=l121 sig_type=std_logic lab=gpio_analog[7]}
C {devices/lab_pin.sym} 5090 1420 0 0 {name=l122 sig_type=std_logic lab=gpio_analog[8]}
C {devices/lab_pin.sym} 4350 300 2 0 {name=l123 sig_type=std_logic lab=gpio_analog[7]}
C {devices/lab_pin.sym} 4350 340 2 0 {name=l124 sig_type=std_logic lab=gpio_analog[8]}
C {devices/lab_pin.sym} 4350 420 2 0 {name=l125 sig_type=std_logic lab=gpio_analog[9]}
C {devices/lab_pin.sym} 4350 360 2 0 {name=l126 sig_type=std_logic lab=gpio_analog[10]}
C {devices/lab_pin.sym} 4850 300 2 0 {name=l127 sig_type=std_logic lab=gpio_analog[7]}
C {devices/lab_pin.sym} 4850 340 2 0 {name=l128 sig_type=std_logic lab=gpio_analog[8]}
C {devices/lab_pin.sym} 4850 420 2 0 {name=l129 sig_type=std_logic lab=gpio_analog[9]}
C {devices/lab_pin.sym} 4850 400 2 0 {name=l130 sig_type=std_logic lab=gpio_analog[10]}
C {devices/lab_pin.sym} 5090 1380 0 0 {name=l131 sig_type=std_logic lab=gpio_analog[11]}
C {devices/lab_pin.sym} 4350 380 2 0 {name=l132 sig_type=std_logic lab=gpio_analog[12]}
C {devices/lab_pin.sym} 4350 400 2 0 {name=l133 sig_type=std_logic lab=gpio_analog[13]}
C {devices/lab_pin.sym} 4850 380 2 0 {name=l134 sig_type=std_logic lab=gpio_analog[14]}
C {devices/lab_pin.sym} 4850 360 2 0 {name=l135 sig_type=std_logic lab=gpio_analog[15]}
C {devices/lab_pin.sym} 4180 1400 2 0 {name=l136 sig_type=std_logic lab=io_analog[10]}
C {devices/lab_pin.sym} 4780 1380 2 0 {name=l137 sig_type=std_logic lab=gpio_analog[16]}
C {devices/lab_pin.sym} 5410 1400 2 0 {name=l138 sig_type=std_logic lab=gpio_analog[17]}
C {devices/lab_pin.sym} 4180 1310 2 0 {name=l139 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 4180 1350 2 0 {name=l140 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 4460 1310 0 0 {name=l141 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 4460 1350 0 0 {name=l142 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 5410 1310 2 0 {name=l143 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} 5410 1350 2 0 {name=l144 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 4350 160 2 0 {name=l145 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} 4850 160 2 0 {name=l146 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} 4180 1380 2 0 {name=l147 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 4180 1420 2 0 {name=l148 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 4460 1420 0 0 {name=l149 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 5410 1420 2 0 {name=l150 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 4350 320 2 0 {name=l151 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 4850 320 2 0 {name=l152 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 4460 1380 0 0 {name=l153 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 5410 1380 2 0 {name=l154 sig_type=std_logic lab=vdda2}
