v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1980 420 1990 420 {
lab=vssa2}
N 1980 470 1990 470 {
lab=vssa1}
N 1980 520 1990 520 {
lab=vssa2}
N 1980 570 1990 570 {
lab=vssa2}
N 1980 400 1990 400 {
lab=vccd2}
N 1980 450 1990 450 {
lab=vccd1}
N 1980 500 1990 500 {
lab=vdda2}
N 1980 550 1990 550 {
lab=vdda2}
N 2290 400 2300 400 {
lab=v02}
N 2290 450 2300 450 {
lab=v04}
N 2290 500 2300 500 {
lab=v25}
N 2290 550 2300 550 {
lab=v3}
N 2330 1660 2340 1660 {
lab=gpio_analog[0]}
N 2330 1730 2340 1730 {
lab=gpio_analog[7]}
N 2930 1680 2940 1680 {
lab=gpio_analog[0]}
N 3560 1680 3570 1680 {
lab=gpio_analog[0]}
N 3560 1700 3570 1700 {
lab=gpio_analog[1]}
N 2890 320 2900 320 {
lab=gpio_analog[0]}
N 2890 360 2900 360 {
lab=gpio_analog[1]}
N 2890 440 2900 440 {
lab=gpio_analog[2]}
N 2890 380 2900 380 {
lab=gpio_analog[3]}
N 3390 440 3400 440 {
lab=gpio_analog[2]}
N 3390 420 3400 420 {
lab=gpio_analog[3]}
N 3390 320 3400 320 {
lab=gpio_analog[0]}
N 3390 360 3400 360 {
lab=gpio_analog[1]}
N 3560 1660 3570 1660 {
lab=gpio_analog[4]}
N 3870 1680 3880 1680 {
lab=io_analog[9]}
N 2890 400 2900 400 {
lab=io_analog[0]}
N 2890 420 2900 420 {
lab=io_analog[1]}
N 3390 400 3400 400 {
lab=io_analog[2]}
N 3390 380 3400 380 {
lab=io_analog[3]}
N 3240 1660 3250 1660 {
lab=io_analog[8]}
N 2640 1680 2650 1680 {
lab=io_analog[7]}
N 2930 1750 2940 1750 {
lab=gpio_analog[7]}
N 3560 1750 3570 1750 {
lab=gpio_analog[7]}
N 3560 1770 3570 1770 {
lab=gpio_analog[8]}
N 2890 480 2900 480 {
lab=gpio_analog[7]}
N 2890 520 2900 520 {
lab=gpio_analog[8]}
N 2890 600 2900 600 {
lab=gpio_analog[9]}
N 2890 540 2900 540 {
lab=gpio_analog[10]}
N 3390 480 3400 480 {
lab=gpio_analog[7]}
N 3390 520 3400 520 {
lab=gpio_analog[8]}
N 3390 600 3400 600 {
lab=gpio_analog[9]}
N 3390 580 3400 580 {
lab=gpio_analog[10]}
N 3560 1730 3570 1730 {
lab=gpio_analog[11]}
N 2890 560 2900 560 {
lab=gpio_analog[12]}
N 2890 580 2900 580 {
lab=gpio_analog[13]}
N 3390 560 3400 560 {
lab=gpio_analog[14]}
N 3390 540 3400 540 {
lab=gpio_analog[15]}
N 2640 1750 2650 1750 {
lab=io_analog[10]}
N 3240 1730 3250 1730 {
lab=gpio_analog[16]}
N 3870 1750 3880 1750 {
lab=gpio_analog[17]}
N 2640 1660 2650 1660 {
lab=vccd2}
N 2640 1700 2650 1700 {
lab=vssa2}
N 2930 1660 2940 1660 {
lab=vccd2}
N 2930 1700 2940 1700 {
lab=vssa2}
N 3870 1660 3880 1660 {
lab=vdda2}
N 3870 1700 3880 1700 {
lab=vssa2}
N 2890 340 2900 340 {
lab=vssa1}
N 3390 340 3400 340 {
lab=vssa1}
N 2640 1730 2650 1730 {
lab=vccd2}
N 2640 1770 2650 1770 {
lab=vssa2}
N 2930 1770 2940 1770 {
lab=vssa2}
N 3870 1770 3880 1770 {
lab=vssa2}
N 2890 500 2900 500 {
lab=vssa2}
N 3390 500 3400 500 {
lab=vssa2}
N 2930 1730 2940 1730 {
lab=vccd2}
N 3870 1730 3880 1730 {
lab=vdda2}
N 2460 1470 2490 1470 {
lab=vssa2}
N 2460 740 2470 740 {
lab=vssa2}
N 2460 700 2470 700 {
lab=vccd2}
N 2460 780 2530 780 {
lab=#net1}
N 2460 1000 2530 1000 {
lab=#net1}
N 2460 1020 2540 1020 {
lab=#net2}
N 2460 800 2540 800 {
lab=#net2}
N 2460 820 2550 820 {
lab=#net3}
N 2460 1040 2550 1040 {
lab=#net3}
N 2460 840 2560 840 {
lab=#net4}
N 2460 1060 2560 1060 {
lab=#net4}
N 2460 860 2570 860 {
lab=#net5}
N 2460 1080 2570 1080 {
lab=#net5}
N 2460 880 2580 880 {
lab=#net6}
N 2460 1100 2580 1100 {
lab=#net6}
N 2460 1120 2590 1120 {
lab=#net7}
N 2460 900 2590 900 {
lab=#net7}
N 2460 920 2600 920 {
lab=#net8}
N 2460 1140 2600 1140 {
lab=#net8}
N 2130 700 2160 700 {
lab=la_data_in[8]}
N 2130 720 2160 720 {
lab=la_data_in[9]}
N 2130 740 2160 740 {
lab=la_data_in[10]}
N 2130 760 2160 760 {
lab=la_data_in[11]}
N 2130 780 2160 780 {
lab=la_data_in[12]}
N 2130 800 2160 800 {
lab=la_data_in[13]}
N 2130 820 2160 820 {
lab=la_data_in[14]}
N 2130 840 2160 840 {
lab=la_data_in[15]}
N 2010 1330 2160 1330 {
lab=#net9}
N 2010 1350 2160 1350 {
lab=#net10}
N 2010 1370 2160 1370 {
lab=#net11}
N 2010 1390 2160 1390 {
lab=#net12}
N 2010 1410 2160 1410 {
lab=#net13}
N 2010 1430 2160 1430 {
lab=#net14}
N 2010 1450 2160 1450 {
lab=#net15}
N 2010 1470 2160 1470 {
lab=#net16}
N 2010 1310 2030 1310 {
lab=vssa2}
N 1680 1350 1710 1350 {
lab=la_data_in[16]}
N 1680 1370 1710 1370 {
lab=la_data_in[17]}
N 1680 1390 1710 1390 {
lab=la_data_in[18]}
N 1680 1410 1710 1410 {
lab=la_data_in[19]}
N 1680 1430 1710 1430 {
lab=la_data_in[20]}
N 1680 1450 1710 1450 {
lab=la_data_in[21]}
N 1680 1470 1710 1470 {
lab=la_data_in[22]}
N 1680 1490 1710 1490 {
lab=la_data_in[23]}
N 2010 1000 2160 1000 {
lab=#net17}
N 2010 1020 2160 1020 {
lab=#net18}
N 2010 1040 2160 1040 {
lab=#net19}
N 2010 1060 2160 1060 {
lab=#net20}
N 2010 1080 2160 1080 {
lab=#net21}
N 2010 1100 2160 1100 {
lab=#net22}
N 2010 1120 2160 1120 {
lab=#net23}
N 2010 1140 2160 1140 {
lab=#net24}
N 2010 980 2030 980 {
lab=vssa2}
N 2010 960 2030 960 {
lab=vdda2}
N 2010 1290 2030 1290 {
lab=vdda2}
N 1680 1200 1710 1200 {
lab=la_data_in[7]}
N 1680 1180 1710 1180 {
lab=la_data_in[6]}
N 1680 1160 1710 1160 {
lab=la_data_in[5]}
N 1680 1140 1710 1140 {
lab=la_data_in[4]}
N 1680 1120 1710 1120 {
lab=la_data_in[3]}
N 1680 1100 1710 1100 {
lab=la_data_in[2]}
N 1680 1080 1710 1080 {
lab=la_data_in[1]}
N 1680 1060 1710 1060 {
lab=la_data_in[0]}
N 1680 1040 1710 1040 {
lab=v02}
N 1680 1020 1710 1020 {
lab=v3}
N 1680 1000 1710 1000 {
lab=v25}
N 1680 1330 1710 1330 {
lab=vccd2}
N 1680 1310 1710 1310 {
lab=v25}
N 1680 1290 1710 1290 {
lab=la_data_in[24]}
N 1680 980 1710 980 {
lab=la_data_in[25]}
N 1680 960 1710 960 {
lab=la_data_in[24]}
N 2460 760 2470 760 {
lab=la_data_in[25]}
N 2460 720 2470 720 {
lab=v25}
N 2530 780 2530 1000 {
lab=#net1}
N 2540 800 2540 1020 {
lab=#net2}
N 2550 820 2550 1040 {
lab=#net3}
N 2560 840 2560 1060 {
lab=#net4}
N 2570 860 2570 1080 {
lab=#net5}
N 2580 880 2580 1100 {
lab=#net6}
N 2590 900 2590 1120 {
lab=#net7}
N 2600 920 2600 1140 {
lab=#net8}
N 2600 1140 2630 1140 {
lab=#net8}
N 2590 1120 2630 1120 {
lab=#net7}
N 2580 1100 2630 1100 {
lab=#net6}
N 2570 1080 2630 1080 {
lab=#net5}
N 2560 1060 2630 1060 {
lab=#net4}
N 2550 1040 2630 1040 {
lab=#net3}
N 2540 1020 2630 1020 {
lab=#net2}
N 2530 1000 2630 1000 {
lab=#net1}
N 2930 1000 2940 1000 {
lab=vccd2}
N 2930 1020 2940 1020 {
lab=vssa2}
N 2930 1040 2940 1040 {
lab=io_analog[5]}
N 2930 1060 2940 1060 {
lab=vssa2}
N 2120 700 2130 700 {
lab=la_data_in[8]}
N 2120 720 2130 720 {
lab=la_data_in[9]}
N 2120 740 2130 740 {
lab=la_data_in[10]}
N 2120 760 2130 760 {
lab=la_data_in[11]}
N 2120 780 2130 780 {
lab=la_data_in[12]}
N 2120 800 2130 800 {
lab=la_data_in[13]}
N 2120 820 2130 820 {
lab=la_data_in[14]}
N 2120 840 2130 840 {
lab=la_data_in[15]}
N 1670 1060 1680 1060 {
lab=la_data_in[0]}
N 1670 1080 1680 1080 {
lab=la_data_in[1]}
N 1670 1100 1680 1100 {
lab=la_data_in[2]}
N 1670 1120 1680 1120 {
lab=la_data_in[3]}
N 1670 1140 1680 1140 {
lab=la_data_in[4]}
N 1670 1160 1680 1160 {
lab=la_data_in[5]}
N 1670 1180 1680 1180 {
lab=la_data_in[6]}
N 1670 1200 1680 1200 {
lab=la_data_in[7]}
N 1670 980 1680 980 {
lab=la_data_in[25]}
N 1670 960 1680 960 {
lab=la_data_in[24]}
N 1670 1290 1680 1290 {
lab=la_data_in[24]}
N 1670 1350 1680 1350 {
lab=la_data_in[16]}
N 1670 1370 1680 1370 {
lab=la_data_in[17]}
N 1670 1390 1680 1390 {
lab=la_data_in[18]}
N 1670 1410 1680 1410 {
lab=la_data_in[19]}
N 1670 1430 1680 1430 {
lab=la_data_in[20]}
N 1670 1450 1680 1450 {
lab=la_data_in[21]}
N 1670 1470 1680 1470 {
lab=la_data_in[22]}
N 1670 1490 1680 1490 {
lab=la_data_in[23]}
N 2930 1080 2940 1080 {
lab=la_data_out[32]}
N 2930 1100 2940 1100 {
lab=la_data_out[33]}
N 2930 1120 2940 1120 {
lab=la_data_out[34]}
N 2930 1140 2940 1140 {
lab=la_data_out[35]}
N 2930 1160 2940 1160 {
lab=la_data_out[36]}
N 2930 1180 2940 1180 {
lab=la_data_out[37]}
N 2930 1200 2940 1200 {
lab=la_data_out[38]}
N 2930 1220 2940 1220 {
lab=la_data_out[39]}
N 1670 1310 1680 1310 {
lab=v25}
N 1670 1040 1680 1040 {
lab=v02}
N 1670 1020 1680 1020 {
lab=v3}
N 1670 1000 1680 1000 {
lab=v25}
N 1670 1330 1680 1330 {
lab=vccd2}
N 4070 1460 4100 1460 {
lab=vssa1}
N 4070 730 4080 730 {
lab=vssa1}
N 4070 690 4080 690 {
lab=vccd1}
N 4070 770 4140 770 {
lab=#net25}
N 4070 990 4140 990 {
lab=#net25}
N 4070 1010 4150 1010 {
lab=#net26}
N 4070 790 4150 790 {
lab=#net26}
N 4070 810 4160 810 {
lab=#net27}
N 4070 1030 4160 1030 {
lab=#net27}
N 4070 830 4170 830 {
lab=#net28}
N 4070 1050 4170 1050 {
lab=#net28}
N 4070 850 4180 850 {
lab=#net29}
N 4070 1070 4180 1070 {
lab=#net29}
N 4070 870 4190 870 {
lab=#net30}
N 4070 1090 4190 1090 {
lab=#net30}
N 4070 1110 4200 1110 {
lab=#net31}
N 4070 890 4200 890 {
lab=#net31}
N 4070 910 4210 910 {
lab=#net32}
N 4070 1130 4210 1130 {
lab=#net32}
N 3740 690 3770 690 {
lab=la_data_in[91]}
N 3740 710 3770 710 {
lab=la_data_in[92]}
N 3740 730 3770 730 {
lab=la_data_in[93]}
N 3740 750 3770 750 {
lab=la_data_in[94]}
N 3740 770 3770 770 {
lab=la_data_in[95]}
N 3740 790 3770 790 {
lab=la_data_in[96]}
N 3740 810 3770 810 {
lab=la_data_in[97]}
N 3740 830 3770 830 {
lab=la_data_in[98]}
N 3620 1320 3770 1320 {
lab=#net33}
N 3620 1340 3770 1340 {
lab=#net34}
N 3620 1360 3770 1360 {
lab=#net35}
N 3620 1380 3770 1380 {
lab=#net36}
N 3620 1400 3770 1400 {
lab=#net37}
N 3620 1420 3770 1420 {
lab=#net38}
N 3620 1440 3770 1440 {
lab=#net39}
N 3620 1460 3770 1460 {
lab=#net40}
N 3620 1300 3640 1300 {
lab=vssa1}
N 3290 1340 3320 1340 {
lab=la_data_in[99]}
N 3290 1360 3320 1360 {
lab=la_data_in[100]}
N 3290 1380 3320 1380 {
lab=la_data_in[101]}
N 3290 1400 3320 1400 {
lab=la_data_in[102]}
N 3290 1420 3320 1420 {
lab=la_data_in[103]}
N 3290 1440 3320 1440 {
lab=la_data_in[104]}
N 3290 1460 3320 1460 {
lab=la_data_in[105]}
N 3290 1480 3320 1480 {
lab=la_data_in[106]}
N 3620 990 3770 990 {
lab=#net41}
N 3620 1010 3770 1010 {
lab=#net42}
N 3620 1030 3770 1030 {
lab=#net43}
N 3620 1050 3770 1050 {
lab=#net44}
N 3620 1070 3770 1070 {
lab=#net45}
N 3620 1090 3770 1090 {
lab=#net46}
N 3620 1110 3770 1110 {
lab=#net47}
N 3620 1130 3770 1130 {
lab=#net48}
N 3620 970 3640 970 {
lab=vssa1}
N 3620 950 3640 950 {
lab=vdda1}
N 3620 1280 3640 1280 {
lab=vdda1}
N 3290 1190 3320 1190 {
lab=la_data_in[90]}
N 3290 1170 3320 1170 {
lab=la_data_in[89]}
N 3290 1150 3320 1150 {
lab=la_data_in[88]}
N 3290 1130 3320 1130 {
lab=la_data_in[87]}
N 3290 1110 3320 1110 {
lab=la_data_in[86]}
N 3290 1090 3320 1090 {
lab=la_data_in[85]}
N 3290 1070 3320 1070 {
lab=la_data_in[84]}
N 3290 1050 3320 1050 {
lab=la_data_in[83]}
N 3290 1030 3320 1030 {
lab=v04}
N 3290 1010 3320 1010 {
lab=v3}
N 3290 990 3320 990 {
lab=v25}
N 3290 1320 3320 1320 {
lab=vccd1}
N 3290 1300 3320 1300 {
lab=v25}
N 3290 1280 3320 1280 {
lab=la_data_in[107]}
N 3290 970 3320 970 {
lab=la_data_in[108]}
N 3290 950 3320 950 {
lab=la_data_in[107]}
N 4070 750 4080 750 {
lab=la_data_in[108]}
N 4070 710 4080 710 {
lab=v25}
N 4140 770 4140 990 {
lab=#net25}
N 4150 790 4150 1010 {
lab=#net26}
N 4160 810 4160 1030 {
lab=#net27}
N 4170 830 4170 1050 {
lab=#net28}
N 4180 850 4180 1070 {
lab=#net29}
N 4190 870 4190 1090 {
lab=#net30}
N 4200 890 4200 1110 {
lab=#net31}
N 4210 910 4210 1130 {
lab=#net32}
N 4210 1130 4240 1130 {
lab=#net32}
N 4200 1110 4240 1110 {
lab=#net31}
N 4190 1090 4240 1090 {
lab=#net30}
N 4180 1070 4240 1070 {
lab=#net29}
N 4170 1050 4240 1050 {
lab=#net28}
N 4160 1030 4240 1030 {
lab=#net27}
N 4150 1010 4240 1010 {
lab=#net26}
N 4140 990 4240 990 {
lab=#net25}
N 4540 990 4550 990 {
lab=vccd1}
N 4540 1010 4550 1010 {
lab=vssa1}
N 4540 1030 4550 1030 {
lab=io_analog[5]}
N 4540 1050 4550 1050 {
lab=vssa1}
N 3280 1050 3290 1050 {
lab=la_data_in[83]}
N 3280 1070 3290 1070 {
lab=la_data_in[84]}
N 3280 1090 3290 1090 {
lab=la_data_in[85]}
N 3280 1110 3290 1110 {
lab=la_data_in[86]}
N 3280 1130 3290 1130 {
lab=la_data_in[87]}
N 3280 1150 3290 1150 {
lab=la_data_in[88]}
N 3280 1170 3290 1170 {
lab=la_data_in[89]}
N 3280 1190 3290 1190 {
lab=la_data_in[90]}
N 3280 950 3290 950 {
lab=la_data_in[107]}
N 3280 970 3290 970 {
lab=la_data_in[108]}
N 3280 1280 3290 1280 {
lab=la_data_in[107]}
N 3280 1340 3290 1340 {
lab=la_data_in[99]}
N 3280 1360 3290 1360 {
lab=la_data_in[100]}
N 3280 1380 3290 1380 {
lab=la_data_in[101]}
N 3280 1400 3290 1400 {
lab=la_data_in[102]}
N 3280 1420 3290 1420 {
lab=la_data_in[103]}
N 3280 1440 3290 1440 {
lab=la_data_in[104]}
N 3280 1460 3290 1460 {
lab=la_data_in[105]}
N 3280 1480 3290 1480 {
lab=la_data_in[106]}
N 3730 690 3740 690 {
lab=la_data_in[91]}
N 3730 710 3740 710 {
lab=la_data_in[92]}
N 3730 730 3740 730 {
lab=la_data_in[93]}
N 3730 750 3740 750 {
lab=la_data_in[94]}
N 3730 770 3740 770 {
lab=la_data_in[95]}
N 3730 790 3740 790 {
lab=la_data_in[96]}
N 3730 810 3740 810 {
lab=la_data_in[97]}
N 3730 830 3740 830 {
lab=la_data_in[98]}
N 4540 1070 4550 1070 {
lab=la_data_out[113]}
N 4540 1090 4550 1090 {
lab=la_data_out[114]}
N 4540 1110 4550 1110 {
lab=la_data_out[115]}
N 4540 1130 4550 1130 {
lab=la_data_out[116]}
N 4540 1150 4550 1150 {
lab=la_data_out[117]}
N 4540 1170 4550 1170 {
lab=la_data_out[118]}
N 4540 1190 4550 1190 {
lab=la_data_out[119]}
N 4540 1210 4550 1210 {
lab=la_data_out[120]}
N 3280 990 3290 990 {
lab=v25}
N 3280 1300 3290 1300 {
lab=v25}
N 3280 1010 3290 1010 {
lab=v3}
N 3280 1030 3290 1030 {
lab=v04}
N 3280 1320 3290 1320 {
lab=vccd1}
C {devices/iopin.sym} 1280 690 0 0 {name=p1 lab=vdda1}
C {devices/iopin.sym} 1280 720 0 0 {name=p2 lab=vdda2}
C {devices/iopin.sym} 1280 750 0 0 {name=p3 lab=vssa1}
C {devices/iopin.sym} 1280 780 0 0 {name=p4 lab=vssa2}
C {devices/iopin.sym} 1280 810 0 0 {name=p5 lab=vccd1}
C {devices/iopin.sym} 1280 840 0 0 {name=p6 lab=vccd2}
C {devices/iopin.sym} 1280 870 0 0 {name=p7 lab=vssd1}
C {devices/iopin.sym} 1280 900 0 0 {name=p8 lab=vssd2}
C {devices/ipin.sym} 1330 970 0 0 {name=p9 lab=wb_clk_i}
C {devices/ipin.sym} 1330 1000 0 0 {name=p10 lab=wb_rst_i}
C {devices/ipin.sym} 1330 1030 0 0 {name=p11 lab=wbs_stb_i}
C {devices/ipin.sym} 1330 1060 0 0 {name=p12 lab=wbs_cyc_i}
C {devices/ipin.sym} 1330 1090 0 0 {name=p13 lab=wbs_we_i}
C {devices/ipin.sym} 1330 1120 0 0 {name=p14 lab=wbs_sel_i[3:0]}
C {devices/ipin.sym} 1330 1150 0 0 {name=p15 lab=wbs_dat_i[31:0]}
C {devices/ipin.sym} 1330 1180 0 0 {name=p16 lab=wbs_adr_i[31:0]}
C {devices/opin.sym} 1320 1240 0 0 {name=p17 lab=wbs_ack_o}
C {devices/opin.sym} 1320 1270 0 0 {name=p18 lab=wbs_dat_o[31:0]}
C {devices/ipin.sym} 1330 1310 0 0 {name=p19 lab=la_data_in[127:0]}
C {devices/opin.sym} 1320 1340 0 0 {name=p20 lab=la_data_out[127:0]}
C {devices/ipin.sym} 1330 1420 0 0 {name=p21 lab=io_in[26:0]}
C {devices/ipin.sym} 1330 1450 0 0 {name=p22 lab=io_in_3v3[26:0]}
C {devices/ipin.sym} 1320 1730 0 0 {name=p23 lab=user_clock2}
C {devices/opin.sym} 1320 1480 0 0 {name=p24 lab=io_out[26:0]}
C {devices/opin.sym} 1320 1510 0 0 {name=p25 lab=io_oeb[26:0]}
C {devices/iopin.sym} 1290 1570 0 0 {name=p26 lab=gpio_analog[17:0]}
C {devices/iopin.sym} 1290 1600 0 0 {name=p27 lab=gpio_noesd[17:0]}
C {devices/iopin.sym} 1290 1630 0 0 {name=p29 lab=io_analog[10:0]}
C {devices/iopin.sym} 1290 1660 0 0 {name=p30 lab=io_clamp_high[2:0]}
C {devices/iopin.sym} 1290 1690 0 0 {name=p31 lab=io_clamp_low[2:0]}
C {devices/opin.sym} 1310 1760 0 0 {name=p32 lab=user_irq[2:0]}
C {devices/ipin.sym} 1330 1370 0 0 {name=p28 lab=la_oenb[127:0]}
C {vDivider_3.sym} 2140 560 0 0 {name=x5}
C {vDivider_25.sym} 2140 510 0 0 {name=x6}
C {vDivider_02.sym} 2140 410 0 0 {name=x7}
C {vDivider_04.sym} 2140 460 0 0 {name=x8}
C {devices/lab_pin.sym} 1980 570 0 0 {name=l27 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 1980 520 0 0 {name=l28 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 1980 470 0 0 {name=l29 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} 1980 420 0 0 {name=l30 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 1980 400 0 0 {name=l31 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 1980 450 0 0 {name=l32 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} 1980 500 0 0 {name=l33 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} 1980 550 0 0 {name=l34 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} 2300 400 2 0 {name=l35 sig_type=std_logic lab=v02}
C {devices/lab_pin.sym} 2300 450 2 0 {name=l36 sig_type=std_logic lab=v04}
C {devices/lab_pin.sym} 2300 500 2 0 {name=l37 sig_type=std_logic lab=v25}
C {devices/lab_pin.sym} 2300 550 2 0 {name=l38 sig_type=std_logic lab=v3}
C {Buffer.sym} 2490 1680 0 0 {name=x3}
C {Buffer.sym} 2490 1750 0 0 {name=x4}
C {oneBitADC.sym} 3090 1680 0 0 {name=x9}
C {oneBitADC.sym} 3090 1750 0 0 {name=x10}
C {2-1MUX.sym} 3720 1680 0 0 {name=x11}
C {2-1MUX.sym} 3720 1750 0 0 {name=x12}
C {4T4R.sym} 2740 540 0 0 {name=x13}
C {4T4R.sym} 2740 380 0 0 {name=x14}
C {4T4RLarge.sym} 3240 540 0 0 {name=x15}
C {4T4RLarge.sym} 3240 380 0 0 {name=x16}
C {devices/lab_pin.sym} 2330 1660 0 0 {name=l99 sig_type=std_logic lab=gpio_analog[0]}
C {devices/lab_pin.sym} 2930 1680 0 0 {name=l100 sig_type=std_logic lab=gpio_analog[0]}
C {devices/lab_pin.sym} 3560 1680 0 0 {name=l101 sig_type=std_logic lab=gpio_analog[0]}
C {devices/lab_pin.sym} 3560 1700 0 0 {name=l102 sig_type=std_logic lab=gpio_analog[1]}
C {devices/lab_pin.sym} 2900 320 2 0 {name=l103 sig_type=std_logic lab=gpio_analog[0]}
C {devices/lab_pin.sym} 2900 360 2 0 {name=l104 sig_type=std_logic lab=gpio_analog[1]}
C {devices/lab_pin.sym} 2900 440 2 0 {name=l105 sig_type=std_logic lab=gpio_analog[2]}
C {devices/lab_pin.sym} 2900 380 2 0 {name=l106 sig_type=std_logic lab=gpio_analog[3]}
C {devices/lab_pin.sym} 3400 440 2 0 {name=l107 sig_type=std_logic lab=gpio_analog[2]}
C {devices/lab_pin.sym} 3400 420 2 0 {name=l108 sig_type=std_logic lab=gpio_analog[3]}
C {devices/lab_pin.sym} 3400 320 2 0 {name=l109 sig_type=std_logic lab=gpio_analog[0]}
C {devices/lab_pin.sym} 3400 360 2 0 {name=l110 sig_type=std_logic lab=gpio_analog[1]}
C {devices/lab_pin.sym} 3560 1660 0 0 {name=l111 sig_type=std_logic lab=gpio_analog[4]}
C {devices/lab_pin.sym} 3880 1680 2 0 {name=l112 sig_type=std_logic lab=io_analog[9]}
C {devices/lab_pin.sym} 2900 400 2 0 {name=l113 sig_type=std_logic lab=io_analog[0]}
C {devices/lab_pin.sym} 2900 420 2 0 {name=l114 sig_type=std_logic lab=io_analog[1]}
C {devices/lab_pin.sym} 3400 400 2 0 {name=l115 sig_type=std_logic lab=io_analog[2]}
C {devices/lab_pin.sym} 3400 380 2 0 {name=l116 sig_type=std_logic lab=io_analog[3]}
C {devices/lab_pin.sym} 3250 1660 2 0 {name=l117 sig_type=std_logic lab=io_analog[8]}
C {devices/lab_pin.sym} 2650 1680 2 0 {name=l118 sig_type=std_logic lab=io_analog[7]}
C {devices/lab_pin.sym} 2330 1730 0 0 {name=l119 sig_type=std_logic lab=gpio_analog[7]}
C {devices/lab_pin.sym} 2930 1750 0 0 {name=l120 sig_type=std_logic lab=gpio_analog[7]}
C {devices/lab_pin.sym} 3560 1750 0 0 {name=l121 sig_type=std_logic lab=gpio_analog[7]}
C {devices/lab_pin.sym} 3560 1770 0 0 {name=l122 sig_type=std_logic lab=gpio_analog[8]}
C {devices/lab_pin.sym} 2900 480 2 0 {name=l123 sig_type=std_logic lab=gpio_analog[7]}
C {devices/lab_pin.sym} 2900 520 2 0 {name=l124 sig_type=std_logic lab=gpio_analog[8]}
C {devices/lab_pin.sym} 2900 600 2 0 {name=l125 sig_type=std_logic lab=gpio_analog[9]}
C {devices/lab_pin.sym} 2900 540 2 0 {name=l126 sig_type=std_logic lab=gpio_analog[10]}
C {devices/lab_pin.sym} 3400 480 2 0 {name=l127 sig_type=std_logic lab=gpio_analog[7]}
C {devices/lab_pin.sym} 3400 520 2 0 {name=l128 sig_type=std_logic lab=gpio_analog[8]}
C {devices/lab_pin.sym} 3400 600 2 0 {name=l129 sig_type=std_logic lab=gpio_analog[9]}
C {devices/lab_pin.sym} 3400 580 2 0 {name=l130 sig_type=std_logic lab=gpio_analog[10]}
C {devices/lab_pin.sym} 3560 1730 0 0 {name=l131 sig_type=std_logic lab=gpio_analog[11]}
C {devices/lab_pin.sym} 2900 560 2 0 {name=l132 sig_type=std_logic lab=gpio_analog[12]}
C {devices/lab_pin.sym} 2900 580 2 0 {name=l133 sig_type=std_logic lab=gpio_analog[13]}
C {devices/lab_pin.sym} 3400 560 2 0 {name=l134 sig_type=std_logic lab=gpio_analog[14]}
C {devices/lab_pin.sym} 3400 540 2 0 {name=l135 sig_type=std_logic lab=gpio_analog[15]}
C {devices/lab_pin.sym} 2650 1750 2 0 {name=l136 sig_type=std_logic lab=io_analog[10]}
C {devices/lab_pin.sym} 3250 1730 2 0 {name=l137 sig_type=std_logic lab=gpio_analog[16]}
C {devices/lab_pin.sym} 3880 1750 2 0 {name=l138 sig_type=std_logic lab=gpio_analog[17]}
C {devices/lab_pin.sym} 2650 1660 2 0 {name=l139 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 2650 1700 2 0 {name=l140 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 2930 1660 0 0 {name=l141 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 2930 1700 0 0 {name=l142 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 3880 1660 2 0 {name=l143 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} 3880 1700 2 0 {name=l144 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 2900 340 2 0 {name=l145 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} 3400 340 2 0 {name=l146 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} 2650 1730 2 0 {name=l147 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 2650 1770 2 0 {name=l148 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 2930 1770 0 0 {name=l149 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 3880 1770 2 0 {name=l150 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 2900 500 2 0 {name=l151 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 3400 500 2 0 {name=l152 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 2930 1730 0 0 {name=l153 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 3880 1730 2 0 {name=l154 sig_type=std_logic lab=vdda2}
C {64T64R.sym} 2310 1230 0 0 {name=x1}
C {8LineSelectInput.sym} 2310 810 0 0 {name=x2}
C {8LineWordInput.sym} 1860 1390 0 0 {name=x17}
C {8LineBitInput.sym} 1860 1080 0 0 {name=x18}
C {8LineSelectOutput02.sym} 2780 1110 0 0 {name=x19}
C {devices/lab_pin.sym} 2120 700 0 0 {name=l9 sig_type=std_logic lab=la_data_in[8]}
C {devices/lab_pin.sym} 2120 720 0 0 {name=l10 sig_type=std_logic lab=la_data_in[9]}
C {devices/lab_pin.sym} 2120 740 0 0 {name=l11 sig_type=std_logic lab=la_data_in[10]}
C {devices/lab_pin.sym} 2120 760 0 0 {name=l12 sig_type=std_logic lab=la_data_in[11]}
C {devices/lab_pin.sym} 2120 780 0 0 {name=l13 sig_type=std_logic lab=la_data_in[12]}
C {devices/lab_pin.sym} 2120 800 0 0 {name=l14 sig_type=std_logic lab=la_data_in[13]}
C {devices/lab_pin.sym} 2120 820 0 0 {name=l15 sig_type=std_logic lab=la_data_in[14]}
C {devices/lab_pin.sym} 2120 840 0 0 {name=l16 sig_type=std_logic lab=la_data_in[15]}
C {devices/lab_pin.sym} 1670 1060 0 0 {name=l1 sig_type=std_logic lab=la_data_in[0]}
C {devices/lab_pin.sym} 1670 1080 0 0 {name=l2 sig_type=std_logic lab=la_data_in[1]}
C {devices/lab_pin.sym} 1670 1100 0 0 {name=l3 sig_type=std_logic lab=la_data_in[2]}
C {devices/lab_pin.sym} 1670 1120 0 0 {name=l4 sig_type=std_logic lab=la_data_in[3]}
C {devices/lab_pin.sym} 1670 1140 0 0 {name=l5 sig_type=std_logic lab=la_data_in[4]}
C {devices/lab_pin.sym} 1670 1160 0 0 {name=l6 sig_type=std_logic lab=la_data_in[5]}
C {devices/lab_pin.sym} 1670 1180 0 0 {name=l7 sig_type=std_logic lab=la_data_in[6]}
C {devices/lab_pin.sym} 1670 1200 0 0 {name=l8 sig_type=std_logic lab=la_data_in[7]}
C {devices/lab_pin.sym} 1670 1290 0 0 {name=l25 sig_type=std_logic lab=la_data_in[24]}
C {devices/lab_pin.sym} 1670 980 0 0 {name=l26 sig_type=std_logic lab=la_data_in[25]}
C {devices/lab_pin.sym} 1670 1350 0 0 {name=l17 sig_type=std_logic lab=la_data_in[16]}
C {devices/lab_pin.sym} 1670 1370 0 0 {name=l18 sig_type=std_logic lab=la_data_in[17]}
C {devices/lab_pin.sym} 1670 1390 0 0 {name=l19 sig_type=std_logic lab=la_data_in[18]}
C {devices/lab_pin.sym} 1670 1410 0 0 {name=l20 sig_type=std_logic lab=la_data_in[19]}
C {devices/lab_pin.sym} 1670 1430 0 0 {name=l21 sig_type=std_logic lab=la_data_in[20]}
C {devices/lab_pin.sym} 1670 1450 0 0 {name=l22 sig_type=std_logic lab=la_data_in[21]}
C {devices/lab_pin.sym} 1670 1470 0 0 {name=l23 sig_type=std_logic lab=la_data_in[22]}
C {devices/lab_pin.sym} 1670 1490 0 0 {name=l24 sig_type=std_logic lab=la_data_in[23]}
C {devices/lab_pin.sym} 2940 1080 2 0 {name=l39 sig_type=std_logic lab=la_data_out[32]}
C {devices/lab_pin.sym} 2940 1100 2 0 {name=l40 sig_type=std_logic lab=la_data_out[33]}
C {devices/lab_pin.sym} 2940 1120 2 0 {name=l41 sig_type=std_logic lab=la_data_out[34]}
C {devices/lab_pin.sym} 2940 1140 2 0 {name=l42 sig_type=std_logic lab=la_data_out[35]}
C {devices/lab_pin.sym} 2940 1160 2 0 {name=l43 sig_type=std_logic lab=la_data_out[36]}
C {devices/lab_pin.sym} 2940 1180 2 0 {name=l44 sig_type=std_logic lab=la_data_out[37]}
C {devices/lab_pin.sym} 2940 1200 2 0 {name=l45 sig_type=std_logic lab=la_data_out[38]}
C {devices/lab_pin.sym} 2940 1220 2 0 {name=l46 sig_type=std_logic lab=la_data_out[39]}
C {devices/lab_pin.sym} 2030 960 2 0 {name=l51 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} 2030 1290 2 0 {name=l47 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} 2030 980 2 0 {name=l54 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 2030 1310 2 0 {name=l48 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 1670 1000 0 0 {name=l49 sig_type=std_logic lab=v25}
C {devices/lab_pin.sym} 1670 960 0 0 {name=l50 sig_type=std_logic lab=la_data_in[24]}
C {devices/lab_pin.sym} 1670 1020 0 0 {name=l52 sig_type=std_logic lab=v3}
C {devices/lab_pin.sym} 1670 1040 0 0 {name=l53 sig_type=std_logic lab=v02}
C {devices/lab_pin.sym} 1670 1310 0 0 {name=l55 sig_type=std_logic lab=v25}
C {devices/lab_pin.sym} 1670 1330 0 0 {name=l56 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 2490 1470 2 0 {name=l57 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 2470 740 2 0 {name=l58 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 2470 760 2 0 {name=l59 sig_type=std_logic lab=la_data_in[25]}
C {devices/lab_pin.sym} 2940 1060 2 0 {name=l60 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 2940 1020 2 0 {name=l61 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} 2940 1040 2 0 {name=l62 sig_type=std_logic lab=io_analog[5]}
C {devices/lab_pin.sym} 2940 1000 2 0 {name=l63 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} 2470 720 2 0 {name=l64 sig_type=std_logic lab=v25}
C {devices/lab_pin.sym} 2470 700 2 0 {name=l65 sig_type=std_logic lab=vccd2}
C {64T64R.sym} 3920 1220 0 0 {name=x20}
C {8LineSelectInput.sym} 3920 800 0 0 {name=x21}
C {8LineWordInput.sym} 3470 1380 0 0 {name=x22}
C {8LineBitInput.sym} 3470 1070 0 0 {name=x23}
C {8LineSelectOutput04.sym} 4390 1100 0 0 {name=x24}
C {devices/lab_pin.sym} 3280 1050 0 0 {name=l66 sig_type=std_logic lab=la_data_in[83]}
C {devices/lab_pin.sym} 3280 1070 0 0 {name=l67 sig_type=std_logic lab=la_data_in[84]}
C {devices/lab_pin.sym} 3280 1090 0 0 {name=l68 sig_type=std_logic lab=la_data_in[85]}
C {devices/lab_pin.sym} 3280 1110 0 0 {name=l69 sig_type=std_logic lab=la_data_in[86]}
C {devices/lab_pin.sym} 3280 1130 0 0 {name=l70 sig_type=std_logic lab=la_data_in[87]}
C {devices/lab_pin.sym} 3280 1150 0 0 {name=l71 sig_type=std_logic lab=la_data_in[88]}
C {devices/lab_pin.sym} 3280 1170 0 0 {name=l72 sig_type=std_logic lab=la_data_in[89]}
C {devices/lab_pin.sym} 3280 1190 0 0 {name=l73 sig_type=std_logic lab=la_data_in[90]}
C {devices/lab_pin.sym} 3280 950 0 0 {name=l80 sig_type=std_logic lab=la_data_in[107]}
C {devices/lab_pin.sym} 3280 970 0 0 {name=l81 sig_type=std_logic lab=la_data_in[108]}
C {devices/lab_pin.sym} 3280 1280 0 0 {name=l74 sig_type=std_logic lab=la_data_in[107]}
C {devices/lab_pin.sym} 3280 1340 0 0 {name=l75 sig_type=std_logic lab=la_data_in[99]}
C {devices/lab_pin.sym} 3280 1360 0 0 {name=l76 sig_type=std_logic lab=la_data_in[100]}
C {devices/lab_pin.sym} 3280 1380 0 0 {name=l77 sig_type=std_logic lab=la_data_in[101]}
C {devices/lab_pin.sym} 3280 1400 0 0 {name=l78 sig_type=std_logic lab=la_data_in[102]}
C {devices/lab_pin.sym} 3280 1420 0 0 {name=l79 sig_type=std_logic lab=la_data_in[103]}
C {devices/lab_pin.sym} 3280 1440 0 0 {name=l82 sig_type=std_logic lab=la_data_in[104]}
C {devices/lab_pin.sym} 3280 1460 0 0 {name=l83 sig_type=std_logic lab=la_data_in[105]}
C {devices/lab_pin.sym} 3280 1480 0 0 {name=l84 sig_type=std_logic lab=la_data_in[106]}
C {devices/lab_pin.sym} 4080 750 2 0 {name=l85 sig_type=std_logic lab=la_data_in[108]}
C {devices/lab_pin.sym} 3730 690 0 0 {name=l86 sig_type=std_logic lab=la_data_in[91]}
C {devices/lab_pin.sym} 3730 710 0 0 {name=l87 sig_type=std_logic lab=la_data_in[92]}
C {devices/lab_pin.sym} 3730 730 0 0 {name=l88 sig_type=std_logic lab=la_data_in[93]}
C {devices/lab_pin.sym} 3730 750 0 0 {name=l89 sig_type=std_logic lab=la_data_in[94]}
C {devices/lab_pin.sym} 3730 770 0 0 {name=l90 sig_type=std_logic lab=la_data_in[95]}
C {devices/lab_pin.sym} 3730 790 0 0 {name=l91 sig_type=std_logic lab=la_data_in[96]}
C {devices/lab_pin.sym} 3730 810 0 0 {name=l92 sig_type=std_logic lab=la_data_in[97]}
C {devices/lab_pin.sym} 3730 830 0 0 {name=l93 sig_type=std_logic lab=la_data_in[98]}
C {devices/lab_pin.sym} 4550 1070 2 0 {name=l94 sig_type=std_logic lab=la_data_out[113]}
C {devices/lab_pin.sym} 4550 1090 2 0 {name=l95 sig_type=std_logic lab=la_data_out[114]}
C {devices/lab_pin.sym} 4550 1110 2 0 {name=l96 sig_type=std_logic lab=la_data_out[115]}
C {devices/lab_pin.sym} 4550 1130 2 0 {name=l97 sig_type=std_logic lab=la_data_out[116]}
C {devices/lab_pin.sym} 4550 1150 2 0 {name=l98 sig_type=std_logic lab=la_data_out[117]}
C {devices/lab_pin.sym} 4550 1170 2 0 {name=l155 sig_type=std_logic lab=la_data_out[118]}
C {devices/lab_pin.sym} 4550 1190 2 0 {name=l156 sig_type=std_logic lab=la_data_out[119]}
C {devices/lab_pin.sym} 4550 1210 2 0 {name=l157 sig_type=std_logic lab=la_data_out[120]}
C {devices/lab_pin.sym} 3640 950 2 0 {name=l158 sig_type=std_logic lab=vdda1}
C {devices/lab_pin.sym} 3640 1280 2 0 {name=l159 sig_type=std_logic lab=vdda1}
C {devices/lab_pin.sym} 4550 990 2 0 {name=l160 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} 4080 690 2 0 {name=l161 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} 4080 710 2 0 {name=l162 sig_type=std_logic lab=v25}
C {devices/lab_pin.sym} 3640 970 2 0 {name=l163 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} 4080 730 2 0 {name=l164 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} 3640 1300 2 0 {name=l165 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} 4100 1460 2 0 {name=l166 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} 4550 1050 2 0 {name=l167 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} 4550 1010 2 0 {name=l168 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} 4550 1030 2 0 {name=l169 sig_type=std_logic lab=io_analog[5]}
C {devices/lab_pin.sym} 3280 990 0 0 {name=l170 sig_type=std_logic lab=v25}
C {devices/lab_pin.sym} 3280 1300 0 0 {name=l171 sig_type=std_logic lab=v25}
C {devices/lab_pin.sym} 3280 1010 0 0 {name=l172 sig_type=std_logic lab=v3}
C {devices/lab_pin.sym} 3280 1030 0 0 {name=l173 sig_type=std_logic lab=v04}
C {devices/lab_pin.sym} 3280 1320 0 0 {name=l174 sig_type=std_logic lab=vccd1}
